<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Radio_Presidio_Prototype</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PI</value></param>
<param><key>value</key><value>3.1415926</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>afscratchvolume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@2:7,1,1,1</value></param>
<param><key>label</key><value>Audio Scratch Volume</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>0 if not tritoneswitch else 1</value></param>
<param><key>gui_hint</key><value>tab@2:1,3,1,1</value></param>
<param><key>label</key><value>Tri-Tone Amplitude</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@1:1,3,1,1</value></param>
<param><key>label</key><value>Heterodyne Amplitude Output</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audiofftmagnification</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab2@1</value></param>
<param><key>label</key><value>Magnification</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audiofftmagnification</value></param>
<param><key>value</key><value>15</value></param>
<param><key>gui_hint</key><value>tab@5:0,1,1,1</value></param>
<param><key>label</key><value>Audio FFT Magnification Factor</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audiofftmagnification</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>cwkey</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:4,1,1,1</value></param>
<param><key>label</key><value>CW Key</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>finerxfirtune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:3,2,1,3</value></param>
<param><key>label</key><value>RX FIR Fine Tuning</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>finetxfirtune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:3,2,1,3</value></param>
<param><key>label</key><value>TX FIR Fine Tuning</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>firfiletxamplitude</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@1:2,1,1,1</value></param>
<param><key>label</key><value>TX FIR File Multiplier</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firrate</value></param>
<param><key>value</key><value>audio_rate * 4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_deviation</value></param>
<param><key>value</key><value>4.5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_shift</value></param>
<param><key>value</key><value>-30e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>integratedecimation</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@4</value></param>
<param><key>label</key><value>Integration Decimation</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label</value></param>
<param><key>value</key><value>rxfreq  + (rxoffset)</value></param>
<param><key>gui_hint</key><value>tab@0:0,3,1,2</value></param>
<param><key>label</key><value>RX FIR Actual Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lnagain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:1,1,1,1</value></param>
<param><key>label</key><value>BladeRF RX LNA Gain (dB)</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>3</value></param>
<param><key>stop</key><value>6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>micvolume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@2:0,2,1,1</value></param>
<param><key>label</key><value>Microphone Input Volume</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>mute</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:0,0,1,1</value></param>
<param><key>label</key><value>Mute RX Audio during TX</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>muteaudioout</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:6,2,1,1</value></param>
<param><key>label</key><value>Audio Mute</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbfmrxrate</value></param>
<param><key>value</key><value>audio_rate * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbfmtxrate</value></param>
<param><key>value</key><value>192000 *2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>noisevolume</value></param>
<param><key>value</key><value>.3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:6,3,3,1</value></param>
<param><key>label</key><value>Noise Volume</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_freq</value></param>
<param><key>value</key><value>309441</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>pltone</value></param>
<param><key>value</key><value>100</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@2:1,2,1,1</value></param>
<param><key>label</key><value>PL Tone Signal (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pltone</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@2:1,2,1,1</value></param>
<param><key>label</key><value>PL Tone Frequency</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>500</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>pltone_0</value></param>
<param><key>value</key><value>0 if not pltoneswitch else .2</value></param>
<param><key>gui_hint</key><value>tab@2:1,1,1,1</value></param>
<param><key>label</key><value>PL Tone Signal Amplitude</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>pltoneswitch</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:1,0,1,1</value></param>
<param><key>label</key><value>Generate PL Tone</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>protect</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:3,1,1,1</value></param>
<param><key>label</key><value>Zero RX gains if TX</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>readafscratch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:7,3,1,1</value></param>
<param><key>label</key><value>Read AF from File</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:0,0,1,1</value></param>
<param><key>label</key><value>RX</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxagcswitch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:5,0,1,1</value></param>
<param><key>label</key><value>Enable RX Audio AGC</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxaudiohigh</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>gui_hint</key><value>tab@2:3,2,1,1</value></param>
<param><key>label</key><value>RX Audio Low Pass (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxaudiolow</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@2:3,1,1,1</value></param>
<param><key>label</key><value>RX Audio High Pass (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxaudioskirt</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@2:3,3,1,1</value></param>
<param><key>label</key><value>RX Audio Filter Skirt (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxbandwidth</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:4,2,1,1</value></param>
<param><key>label</key><value>BladeRF RX Bandwidth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxdata</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@3:0,0,1,1</value></param>
<param><key>label</key><value>Enable RX Data Modulation</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rxdatamodulation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@3:0,2,1,1</value></param>
<param><key>label0</key><value>ATSC Television</value></param>
<param><key>label</key><value>RX Data Modulation</value></param>
<param><key>num_opts</key><value>1</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxfilterswitch</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:3,0,1,1</value></param>
<param><key>label</key><value>Filter RX Audio</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxfirfile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@0:4,0,1,1</value></param>
<param><key>label</key><value>Read FIR File</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxfirfilterskirt</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>gui_hint</key><value>tab@4:1,2,1,1</value></param>
<param><key>label</key><value>RX FIR Filter Skirt</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>100000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxfirswitch</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@0:3,0,1,1</value></param>
<param><key>label</key><value>Write FIR File</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxfirtuning</value></param>
<param><key>value</key><value>-100000</value></param>
<param><key>gui_hint</key><value>tab@0:0,2,1,1</value></param>
<param><key>label</key><value>RX FIR Frequency Offset</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxfirwidth</value></param>
<param><key>value</key><value>20000</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@0:0,3,1,1</value></param>
<param><key>label</key><value>RX FIR Window Width (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxfirwidth</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>gui_hint</key><value>tab@4:1,1,1,1</value></param>
<param><key>label</key><value>RX FIR Filter Width</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>200000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxfreq</value></param>
<param><key>value</key><value>444100000</value></param>
<param><key>gui_hint</key><value>tab@0:0,1,1,1</value></param>
<param><key>label</key><value>BladeRF RX  Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxiqswitch</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@0:4,4,1,1</value></param>
<param><key>label</key><value>Save RX IQ Data to File</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rxmodulation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@4:0,1,1,1</value></param>
<param><key>label0</key><value>Narrow Band FM</value></param>
<param><key>label1</key><value>Wide Band FM</value></param>
<param><key>label2</key><value>Amplitude Modulation</value></param>
<param><key>label3</key><value>Upper Side Band</value></param>
<param><key>label4</key><value>Lower Side Band</value></param>
<param><key>label</key><value>RX Modulation</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxoffset</value></param>
<param><key>value</key><value>0 + firtuning</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@0:3,2,1,3</value></param>
<param><key>label</key><value>RX FIR Fine Tuning</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2500 + firtuning</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2500 + firtuning</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxoffset</value></param>
<param><key>value</key><value>(finerxfirtune+rxfirtuning)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rxoutputgain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>tab@2:5,1,1,1</value></param>
<param><key>label</key><value>RX Output Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rxsource</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:4,3,1,1</value></param>
<param><key>label0</key><value>BladeRF USB Radio Card</value></param>
<param><key>label1</key><value>IQ Sampled Data File</value></param>
<param><key>label2</key><value>Null Source</value></param>
<param><key>label</key><value>RX Source</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rxtx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:6,1,1,1</value></param>
<param><key>label</key><value>Enable TX RXed Audio</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxvga1gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>tab@0:1,2,1,1</value></param>
<param><key>label</key><value>BladeRF RX VGA1 Gain (dB)</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxvga2gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:1,3,1,1</value></param>
<param><key>label</key><value>BladeRF RXVGA2 Gain (dB)</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxvolume</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>tab@2:0,1,1,1</value></param>
<param><key>label</key><value>RX Audio Output Volume</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5376000</value></param>
<param><key>gui_hint</key><value>tab@0:4,1,1,1</value></param>
<param><key>label</key><value>Flowgraph Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1920000 * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>saveaudio</value></param>
<param><key>value</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@5:5,0,1,1</value></param>
<param><key>label</key><value>Write WAV</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_0</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>-75</value></param>
<param><key>gui_hint</key><value>tab@2:5,2,1,2</value></param>
<param><key>label</key><value>RX Power Squelch (dBFS)</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>2400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>4500000.0 / 286 * 684</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>toneone</value></param>
<param><key>value</key><value>783.99</value></param>
<param><key>gui_hint</key><value>tab@2:2,1,1,1</value></param>
<param><key>label</key><value>Tone One Frequency: (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tonethree</value></param>
<param><key>value</key><value>1318.5</value></param>
<param><key>gui_hint</key><value>tab@2:2,3,1,1</value></param>
<param><key>label</key><value>Tone Three Frequency: (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tonetwo</value></param>
<param><key>value</key><value>1046.5</value></param>
<param><key>gui_hint</key><value>tab@2:2,2,1,1</value></param>
<param><key>label</key><value>Tone Two Frequency: (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tritoneswitch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:2,0,1,1</value></param>
<param><key>label</key><value>Generate Tri-Tone</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@1:0,0,1,1</value></param>
<param><key>label</key><value>TX</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>txagcswitch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:6,0,1,1</value></param>
<param><key>label</key><value>Enable TX Audio AGC</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txaudiohigh</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>gui_hint</key><value>tab@2:4,2,1,1</value></param>
<param><key>label</key><value>TX Audio Low Pass (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txaudiolow</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@2:4,1,1,1</value></param>
<param><key>label</key><value>TX Audio High Pass (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txaudioskirt</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@2:4,3,1,1</value></param>
<param><key>label</key><value>TX Audio Filter Skirt (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txbandwidth</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:4,2,1,1</value></param>
<param><key>label</key><value>BladeRF TX Bandwidth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>txdata</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@3:1,0,1,1</value></param>
<param><key>label</key><value>Enable TX Data Modulation</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>txdatamodulation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@3:1,2,1,1</value></param>
<param><key>label0</key><value>ATSC Television</value></param>
<param><key>label</key><value>TX Data Modulation</value></param>
<param><key>num_opts</key><value>1</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txfiltergain</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>txfilterswitch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:4,0,1,1</value></param>
<param><key>label</key><value>Filter TX Audio</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>txfirdisplay</value></param>
<param><key>value</key><value>txfreq  + (txoffset)</value></param>
<param><key>gui_hint</key><value>tab@1:0,3,1,1</value></param>
<param><key>label</key><value>TX FIR Actual Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>txfirfile</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@1:2,2,1,1</value></param>
<param><key>label</key><value>TX FIR File</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txfirfilterskirt</value></param>
<param><key>value</key><value>70000</value></param>
<param><key>gui_hint</key><value>tab@4:3,2,1,1</value></param>
<param><key>label</key><value>TX FIR Filter Skirt</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1000</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txfirfilterskirt</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>txfirfilterwidth/10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txfirfilterwidth</value></param>
<param><key>value</key><value>100000</value></param>
<param><key>gui_hint</key><value>tab@4:3,1,1,1</value></param>
<param><key>label</key><value>TX FIR Filter Width</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txfirfilterwidth</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>samp_rate / nbfmtxrate * 20000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txfirgain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
<param><key>label</key><value>TX FIR Filter Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txfirtuning</value></param>
<param><key>value</key><value>-100000</value></param>
<param><key>gui_hint</key><value>tab@1:0,2,1,1</value></param>
<param><key>label</key><value>TX FIR Signal Offset</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>value</key><value>449100000</value></param>
<param><key>gui_hint</key><value>tab@1:0,1,1,1</value></param>
<param><key>label</key><value>Blade RF TX Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>txmodulation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@4:0,2,1,1</value></param>
<param><key>label0</key><value>Narrow Band FM</value></param>
<param><key>label1</key><value>Wide Band FM</value></param>
<param><key>label2</key><value>Amplitude Modulation</value></param>
<param><key>label3</key><value>Upper Side Band</value></param>
<param><key>label4</key><value>Lower Side Band</value></param>
<param><key>label</key><value>TX Modulation</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txoffset</value></param>
<param><key>value</key><value>(finetxfirtune+txfirtuning)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txoutputgain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
<param><key>label</key><value>TX Output Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>txsink</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:4,3,1,1</value></param>
<param><key>label0</key><value>BladeRF USB Radio Card</value></param>
<param><key>label1</key><value>IQ Sampled Data File</value></param>
<param><key>label2</key><value>Null Sink</value></param>
<param><key>label</key><value>TX Sink</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txvga1gain</value></param>
<param><key>value</key><value>-35</value></param>
<param><key>gui_hint</key><value>tab@1:1,1,1,1</value></param>
<param><key>label</key><value>BladeRF TX VGA1 Gain (dB)</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-35</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txvga2gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:1,2,1,1</value></param>
<param><key>label</key><value>BladeRF TX VGA2 Gain (dB)</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>txwidth</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@1:0,3,1,1</value></param>
<param><key>label</key><value>TX FIR Window Width (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>variable_config_0</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>key</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wavvolume</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:0,3,1,1</value></param>
<param><key>label</key><value>WAV Input Volume</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbfmrxrate</value></param>
<param><key>value</key><value>audio_rate * 4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wbfmtxrate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>writeafscratch</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:6,3,1,1</value></param>
<param><key>label</key><value>Write AF to File</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>Osmocom_RX</value></param>
<param><key>bb_gain0</key><value>0 if (tx and protect) else rxvga2gain</value></param>
<param><key>bw0</key><value>rxbandwidth</value></param>
<param><key>freq0</key><value>rxfreq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>5 if (tx and protect) else rxvga1gain</value></param>
<param><key>gain0</key><value>0 if (tx and protect) else lnagain</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>args</key><value>bladerf=0,xb200,verbosity=verbose,buffers=128</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>afscratchvolumeblock</value></param>
<param><key>const</key><value>afscratchvolume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>.1</value></param>
<param><key>decay_rate</key><value>.1</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>1 if not txagcswitch else 65536</value></param>
<param><key>reference</key><value>1.0 </value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>0.001</value></param>
<param><key>decay_rate</key><value>10</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>1 if not rxagcswitch else 65536</value></param>
<param><key>reference</key><value>.8</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_1</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>0.00001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>5</value></param>
<param><key>reference</key><value>3.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>4</value></param>
<param><key>audio_pass</key><value>47000</value></param>
<param><key>audio_stop</key><value>48000</value></param>
<param><key>chan_rate</key><value>384000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>max_dev</key><value>5000</value></param>
<param><key>quad_rate</key><value>nbfmrxrate * 2</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>max_dev</key><value>10000</value></param>
<param><key>quad_rate</key><value>nbfmtxrate</value></param>
<param><key>tau</key><value>150e-6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_1_0_0</value></param>
<param><key>alpha</key><value>0.02</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>amplitude if tx else 0</value></param>
<param><key>freq</key><value>txoffset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>pltone_0</value></param>
<param><key>freq</key><value>pltone</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_2</value></param>
<param><key>amp</key><value>ampl</value></param>
<param><key>freq</key><value>tonetwo</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_2_0</value></param>
<param><key>amp</key><value>ampl</value></param>
<param><key>freq</key><value>tonethree</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_3</value></param>
<param><key>amp</key><value>0.9</value></param>
<param><key>freq</key><value>-3000000+pilot_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>symbol_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_4</value></param>
<param><key>amp</key><value>cwkey</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>ampl</value></param>
<param><key>freq</key><value>toneone</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>wbfmrxrate / audio_rate</value></param>
<param><key>quad_rate</key><value>wbfmrxrate </value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>75e3 </value></param>
<param><key>quad_rate</key><value>192000</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>alias</key><value>3</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>96000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>audioinputadd</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>audio_rate / 2</value></param>
<param><key>low_cutoff_freq</key><value>50</value></param>
<param><key>samp_rate</key><value>96000</value></param>
<param><key>width</key><value>50</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>gain</key><value>txfiltergain</value></param>
<param><key>high_cutoff_freq</key><value>5000</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>200</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>gain</key><value>txfiltergain</value></param>
<param><key>high_cutoff_freq</key><value>-200</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>-5000</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_1</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>gain</key><value>txfiltergain</value></param>
<param><key>high_cutoff_freq</key><value>10000</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>-10000</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-50</value></param>
<param><key>low_cutoff_freq</key><value>-audio_rate / 2</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>50</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>baudline_sink</key>
<param><key>id</key><value>baudline_sink_0</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>channel_count</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>extra</key><value>{}</value></param>
<param><key>fft_size</key><value>0</value></param>
<param><key>jump_step</key><value>0</value></param>
<param><key>kill_on_del</key><value>True</value></param>
<param><key>memory</key><value>0</value></param>
<param><key>mode</key><value>pipe</value></param>
<param><key>overlap</key><value>0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate / 14</value></param>
<param><key>scale</key><value>1.0</value></param>
<param><key>slide_size</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>x_slip</key><value>0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>txmodulation</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>5</value></param>
<param><key>output_index</key><value>txmodulation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0_0</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>input_index</key><value>rxmodulation</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>txfirfile</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>tx</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_2</value></param>
<param><key>input_index</key><value>rxfirfile</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_3</value></param>
<param><key>input_index</key><value>txdata</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>6</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>"/home/goatman/radiodata/afscratch.raw" if writeafscratch else "/dev/null"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>file</key><value>"/home/goatman/radiodata/rxiqfile.iq" if rxiqswitch else "/dev/null"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0_0</value></param>
<param><key>file</key><value>/home/goatman/radiodata/txiqfile.iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0_1</value></param>
<param><key>file</key><value>"/home/goatman/radiodata/rxfirfile.iq" if rxfirswitch else "/dev/null"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>file</key><value>/home/goatman/radiodata/rxiqfile.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/goatman/radiodata/advatsc.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>file</key><value>/home/goatman/radiodata/rxfirfile.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>"/home/goatman/radiodata/afscratch.raw" if readafscratch else "/dev/zero"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1_0</value></param>
<param><key>file</key><value>"/home/goatman/radiodata/rxfirfile.iq" if rxfirfile else "/dev/zero"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>audiofftmagnification * 10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>832</value></param>
<param><key>n</key><value>1024</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>4</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>wavvolume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0 if (tx and mute) else rxvolume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>micvolume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>firfiletxamplitude</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>rxoutputgain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0_0_3</value></param>
<param><key>const</key><value>rxoutputgain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0_0_3_0</value></param>
<param><key>const</key><value>rxoutputgain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>.3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_3</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate if (txdata and tx) else 0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>24</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/goatman/radiodata/rx.wav</value></param>
<param><key>samp_rate</key><value>96000</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0_0</value></param>
<param><key>file</key><value>/home/goatman/radiodata/doorbell2.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[symbol + 1.25 for symbol in [-7,-5,-3,-1,1,3,5,7]]</value></param>
</block>
<block>
<key>dtv_atsc_field_sync_mux</key>
<param><key>id</key><value>dtv_atsc_field_sync_mux_0</value></param>
</block>
<block>
<key>dtv_atsc_interleaver</key>
<param><key>id</key><value>dtv_atsc_interleaver_0</value></param>
</block>
<block>
<key>dtv_atsc_pad</key>
<param><key>id</key><value>dtv_atsc_pad_0</value></param>
</block>
<block>
<key>dtv_atsc_randomizer</key>
<param><key>id</key><value>dtv_atsc_randomizer_0</value></param>
</block>
<block>
<key>dtv_atsc_rs_encoder</key>
<param><key>id</key><value>dtv_atsc_rs_encoder_0</value></param>
</block>
<block>
<key>dtv_atsc_trellis_encoder</key>
<param><key>id</key><value>dtv_atsc_trellis_encoder_0</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(0.1, symbol_rate, symbol_rate/2, 0.1152, 100)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>rxoffset</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>decim</key><value>samp_rate / firrate</value></param>
<param><key>maxoutbuf</key><value>10000</value></param>
<param><key>minoutbuf</key><value>2000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,samp_rate,rxfirwidth,rxfirfilterskirt,filter.firdes.WIN_KAISER )</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1</value></param>
<param><key>affinity</key><value>6</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1, samp_rate, txfirfilterwidth,txfirfilterskirt, 40,  firdes.WIN_KAISER, 6.76)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>CPU Saver</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>USB TX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>LSB TX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>AM TX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0</value></param>
<param><key>note</key><value>Heterodyne Generators</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>note</key><value>Audio TX Output</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0</value></param>
<param><key>note</key><value>RX Input</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_0</value></param>
<param><key>note</key><value>USB RX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_0_0</value></param>
<param><key>note</key><value>LSB RX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>AM RX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_10</value></param>
<param><key>note</key><value>RX Output</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_10_0</value></param>
<param><key>note</key><value>RX Volume</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_3</value></param>
<param><key>note</key><value>RX Offset Filters</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_5</value></param>
<param><key>note</key><value>WBFM RX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_6</value></param>
<param><key>note</key><value>NBFM RX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_1</value></param>
<param><key>note</key><value>Modulation Filters</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_2</value></param>
<param><key>note</key><value>WBFM TX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_3</value></param>
<param><key>note</key><value>NBFM TX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_4</value></param>
<param><key>note</key><value>S/N Test Generator </value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_5</value></param>
<param><key>note</key><value>Input Volume</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>txvga1gain if tx else -35</value></param>
<param><key>bw0</key><value>txbandwidth</value></param>
<param><key>freq0</key><value>txfreq</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>txvga2gain if tx else 0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>args</key><value>bladerf=0,xb200,verbosity=verbose,buffers=128</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>10000</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>TX RF Output FFT</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-190</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024 * 2</value></param>
<param><key>gui_hint</key><value>tab2@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1_0</value></param>
<param><key>bw</key><value>rxfirwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>affinity</key><value>5</value></param>
<param><key>fftsize</key><value>4096 * 2</value></param>
<param><key>gui_hint</key><value>tab2@3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>TX Audio Input Scope</value></param>
<param><key>size</key><value>4096 * 2</value></param>
<param><key>srate</key><value>audio_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>RX Audio Output Scope</value></param>
<param><key>size</key><value>4096 * 2</value></param>
<param><key>srate</key><value>audio_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>fftsize</key><value>10240 * 2</value></param>
<param><key>gui_hint</key><value>tab2@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-110</value></param>
<param><key>name</key><value>RX Waterfall</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>rxfirwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>fftsize</key><value>10000 * 2</value></param>
<param><key>gui_hint</key><value>tab2@4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>name</key><value>FIR Waterfall</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.001</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>audio_rate </value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024 * 3</value></param>
<param><key>gui_hint</key><value>tab2@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1_0</value></param>
<param><key>bw</key><value>audio_rate / audiofftmagnification / 10</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024 * 3</value></param>
<param><key>gui_hint</key><value>tab2@5</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-90</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024 * 6</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samp_rate / firrate *2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samp_rate / firrate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_2_0</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samp_rate / nbfmtxrate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samp_rate / audio_rate </value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samp_rate / audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>samp_rate / audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3_0</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>rx_audio_band_pass_filter</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>rxaudiohigh</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>rxaudiolow</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>rxaudioskirt</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>rx_selector</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>5</value></param>
<param><key>output_index</key><value>rxmodulation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>rxaudiofilterselector_0</value></param>
<param><key>input_index</key><value>rxfilterswitch</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>rxsourceselector</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>input_index</key><value>rxsource</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>rx</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>RX</value></param>
<param><key>label1</key><value>TX</value></param>
<param><key>label2</key><value>Audio</value></param>
<param><key>label3</key><value>Data</value></param>
<param><key>label4</key><value>Modulation</value></param>
<param><key>label5</key><value>Instrumentation</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab2</value></param>
<param><key>label0</key><value>Waterfall</value></param>
<param><key>label1</key><value>Audio FFT</value></param>
<param><key>label2</key><value>IQ FFT</value></param>
<param><key>label3</key><value>FIR FFT</value></param>
<param><key>label4</key><value>FIR Waterfall</value></param>
<param><key>label5</key><value>Decimation FFT</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>tx_audio_band_pass_filter</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>txaudiohigh</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>txaudiolow</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>txaudioskirt</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>txdatamodulationselector</value></param>
<param><key>input_index</key><value>txdatamodulation</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>txfilterselector</value></param>
<param><key>input_index</key><value>txfilterswitch</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>txsinkselector</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>txsink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>Osmocom_RX</source_block_id><sink_block_id>rxsourceselector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>afscratchvolumeblock</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_1</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_1_0_0</source_block_id><sink_block_id>rx_selector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_2_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_3</source_block_id><sink_block_id>blocks_multiply_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audioinputadd</source_block_id><sink_block_id>tx_audio_band_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audioinputadd</source_block_id><sink_block_id>txfilterselector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>rational_resampler_xxx_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>baudline_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>qtgui_freq_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_3</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_3</source_block_id><sink_block_id>qtgui_waterfall_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_3</source_block_id><sink_block_id>txsinkselector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blks2_selector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>afscratchvolumeblock</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>band_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audioinputadd</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>rx_audio_band_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>rxaudiofilterselector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>audioinputadd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>rational_resampler_xxx_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0_0_3</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0_0_3_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_2</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rxsourceselector</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>rxsourceselector</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>dtv_atsc_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dtv_atsc_field_sync_mux_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_interleaver_0</source_block_id><sink_block_id>dtv_atsc_trellis_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_pad_0</source_block_id><sink_block_id>dtv_atsc_randomizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_randomizer_0</source_block_id><sink_block_id>dtv_atsc_rs_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_rs_encoder_0</source_block_id><sink_block_id>dtv_atsc_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_trellis_encoder_0</source_block_id><sink_block_id>dtv_atsc_field_sync_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>txdatamodulationselector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_2_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2_0_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>band_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3_0</source_block_id><sink_block_id>band_pass_filter_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_audio_band_pass_filter</source_block_id><sink_block_id>rxaudiofilterselector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_selector</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_selector</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_selector</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0_0_3_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_selector</source_block_id><sink_block_id>rational_resampler_xxx_3</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_selector</source_block_id><sink_block_id>rational_resampler_xxx_3_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxaudiofilterselector_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxaudiofilterselector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxaudiofilterselector_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxaudiofilterselector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxsourceselector</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxsourceselector</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxsourceselector</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxsourceselector</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxsourceselector</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_audio_band_pass_filter</source_block_id><sink_block_id>txfilterselector</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>txdatamodulationselector</source_block_id><sink_block_id>blks2_selector_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>txfilterselector</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txsinkselector</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txsinkselector</source_block_id><sink_block_id>blocks_file_sink_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txsinkselector</source_block_id><sink_block_id>blocks_null_sink_1_3</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
